# Keil uVision project mwlib.uvprojx, settings and files
target mwlib (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32F407VETx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.15.0
  cpu: IRAM(0x20000000,0x00020000) IRAM2(0x10000000,0x00010000) IROM(0x08000000,0x00080000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: mwlib
  c flags: Optim=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: STM32F40_41xxx,USE_STDPERIPH_DRIVER,__FPU_USED,ARM_MATH_CM4
  c include: .\user;.\system;.\fwlib;.\core;.\user\mpu6050;.\user\oled;.\fatfs
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group core
    ./core/: startup_stm32f40_41xxx.s arm_cortexM4lf_math.lib
  group fwlib
    ./fwlib/: misc.c stm32f4xx_adc.c stm32f4xx_can.c stm32f4xx_crc.c stm32f4xx_cryp.c stm32f4xx_cryp_aes.c stm32f4xx_cryp_des.c stm32f4xx_cryp_tdes.c stm32f4xx_dac.c stm32f4xx_dbgmcu.c stm32f4xx_dcmi.c stm32f4xx_dma.c stm32f4xx_dma2d.c stm32f4xx_exti.c stm32f4xx_flash.c stm32f4xx_flash_ramfunc.c stm32f4xx_fsmc.c stm32f4xx_gpio.c stm32f4xx_hash.c stm32f4xx_hash_md5.c stm32f4xx_hash_sha1.c stm32f4xx_i2c.c stm32f4xx_iwdg.c stm32f4xx_ltdc.c stm32f4xx_pwr.c stm32f4xx_rcc.c stm32f4xx_rng.c stm32f4xx_rtc.c stm32f4xx_sai.c stm32f4xx_sdio.c stm32f4xx_spi.c stm32f4xx_syscfg.c stm32f4xx_tim.c stm32f4xx_usart.c stm32f4xx_wwdg.c
  group fatfs
    ./fatfs/: diskio.c ff.c ffsystem.c ffunicode.c
  group user
    ./user/: beep.c bmp280.c bsp_iic.c bsp_spi.c dht11.c drv8825.c e18d80nk.c ec11.c gp2y0e03.c gp2y1010.c hallencoder.c hcsr04.c hcsr501.c key.c led.c main.c mq7.c nrf24l01.c pid.c pms7003.c sd.c serialport.c servo.c si7021.c stm32f4xx_it.c system_stm32f4xx.c tb6612fng.c utils.c xkcy25v.c
    ./user/oled/: oled.c
    ./user/mpu6050/: inv_mpu.c inv_mpu_dmp_motion_driver.c mpu6050.c
